# Keil uVision project Lion_1.2.uvprojx, settings and files
target Lion_1.2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F042K6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x200017FF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Lion_1.2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F042x6,USE_HAL_DRIVER,STM32F042x6
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Apps;..\oled;..\Funciones
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group Application/MDK-ARM
    ./: startup_stm32f042x6.s
  group Apps
    ../Apps/: T_Control.c T_Control.h T_Pantalla.c T_Pantalla.h T_Piso.c T_Piso.h T_Sensores.c T_Sensores.h T_Motores.c T_Motores.h
  group Funciones
    ../Funciones/: Estrategias.h Estrategias_LION.c Flash.c Flash.h Funciones.c Funciones.h Funciones_Lion.c Funciones_Lion.h Funciones_pantalla.c Funciones_pantalla.h Iniciar_pines_Lion.c Iniciar_pines_Lion.h Lion1.h
  group Oled
    ../oled/: fonts.c fonts.h ssd1306.c ssd1306.h
  group Application/User
    ../Src/: gpio.c adc.c i2c.c tim.c usart.c stm32f0xx_it.c stm32f0xx_hal_msp.c
    ./: main.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
software components: CMSIS:CORE 5.2.0, CMSIS:RTOS:Keil RTX 4.81.1, Device:Startup 2.3.3
